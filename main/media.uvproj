# Keil uVision project media.uvproj, settings and files
target LCP1700 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: media
  c flags: Optim=4
  c define: __ADC_IRQ
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Files
    ./: startup_LPC17xx.s adcuser.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c KBD.c ADC.c GLCD_SPI_LPC1700.c IRQ.c LED.c ADC.h GLCD.h LED.h media.c tetris.c
  group Startup Files
    ./: core_cm3.c startup_LPC17xx.s system_LPC17xx.c
  group images
    ./: toronto.c jays.c computers.c blubox.c YELLOW.c RED.c audioImageBlur.c audioImage.c tretrisBlur.c tretris.c GalleryBlur.c Gallery.c mainBack.c player.c yellow2.c red2.c
